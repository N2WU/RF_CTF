options:
  parameters:
    author: Corey
    description: Upper Sideband Receiver
    generate_options: qt_gui
    id: zmq_usb_rx
    output_language: python
    title: ZMQ USB Receiver
  states: {}

blocks:
- name: check
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    'true': 'True'
    type: bool
    value: 'False'
  states: {}
- name: ip
  id: variable
  parameters:
    value: '"sdr.rfhackers.com"'
  states: {}
- name: phase_delay
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '10'
    stop: 8e3
    value: '1200'
  states: {}
- name: port
  id: variable
  parameters:
    value: '"6560"'
  states: {}
- name: samp_freq
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '1000'
    step: '1'
    stop: '12000'
    value: '3600'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '96000'
  states: {}
- name: analog_agc2_xx_0
  id: analog_agc2_xx
  parameters:
    attack_rate: '1e-1'
    decay_rate: '50e-6'
    gain: '1.0'
    max_gain: '1'
    reference: '0.8'
    type: complex
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: check
    type: byte
  states: {state: disabled}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: samp_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 10e3
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '16000'
  states: {}
- name: audio_sink_1
  id: audio_sink
  parameters:
    samp_rate: '16000'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '2'
    gain: '1'
    high_cutoff_freq: '3000'
    low_cutoff_freq: '300'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '500'
    win: firdes.WIN_HAMMING
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_and_xx_0
  id: blocks_and_xx
  parameters:
    type: byte
  states: {state: disabled}
- name: blocks_char_to_short_0
  id: blocks_char_to_short
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: phase_delay
    type: float
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\Nolan\Documents\AY22\defcon\data3.dat
    type: float
  states: {state: disabled}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\Nolan\Documents\AY22\defcon\source.dat
    type: float
  states: {state: disabled}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: C:\Users\Nolan\Documents\AY22\defcon\cwdata.bin
    type: byte
  states: {state: disabled}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '1200'
    max_iter: '24000'
    scale: '1'
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: '100e-3'
    init: '0'
    low: '100e-3'
  states: {}
- name: blocks_threshold_ff_0_0
  id: blocks_threshold_ff
  parameters:
    high: '0'
    init: '0'
    low: '0'
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {state: disabled}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 5e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 1e3
    win: firdes.WIN_HAMMING
  states: {}
- name: note_0
  id: note
  parameters:
    note: All standard
  states: {}
- name: note_1
  id: note
  parameters:
    note: threshold for 1s and 0s
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: tabs@2
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: tabs@1
    name: '"RX from " + ip + ":" + port'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: tabs@0
    label1: Data
    label2: Square Wave
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
    update_time: '0.5'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    gui_hint: tabs@0
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: tabs
  id: qtgui_tab_widget
  parameters:
    label0: Tab 0
    label1: Tab 1
    label2: Tab 2
    label3: Tab 3
    num_tabs: '4'
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: '"tcp://"+ip+":"+port'
    timeout: '100'
    type: complex
  states: {}

connections:
- [analog_agc2_xx_0, '0', blocks_complex_to_mag_0, '0']
- [analog_agc2_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [analog_agc2_xx_0, '0', qtgui_time_sink_x_1, '0']
- [analog_const_source_x_0, '0', blocks_and_xx_0, '1']
- [analog_sig_source_x_0, '0', blocks_complex_to_real_0, '0']
- [analog_sig_source_x_1, '0', blocks_multiply_xx_0, '1']
- [band_pass_filter_0, '0', analog_agc2_xx_0, '0']
- [blocks_add_const_vxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_and_xx_0, '0', blocks_char_to_short_0, '0']
- [blocks_and_xx_0, '0', blocks_file_sink_1, '0']
- [blocks_char_to_short_0, '0', blocks_file_sink_1, '0']
- [blocks_complex_to_mag_0, '0', audio_sink_0, '0']
- [blocks_complex_to_mag_0, '0', blocks_threshold_ff_0, '0']
- [blocks_complex_to_real_0, '0', blocks_threshold_ff_0_0, '0']
- [blocks_delay_0, '0', blocks_file_sink_0_0, '0']
- [blocks_delay_0, '0', blocks_null_sink_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_multiply_xx_0, '0']
- [blocks_moving_average_xx_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_multiply_const_vxx_0, '0', blocks_file_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_multiply_xx_0, '0']
- [blocks_multiply_const_vxx_0, '0', digital_binary_slicer_fb_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_xx_0, '0', audio_sink_1, '0']
- [blocks_multiply_xx_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_threshold_ff_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_threshold_ff_0_0, '0', blocks_delay_0, '0']
- [digital_binary_slicer_fb_0, '0', blocks_and_xx_0, '0']
- [low_pass_filter_0, '0', band_pass_filter_0, '0']
- [zeromq_sub_source_0, '0', low_pass_filter_0, '0']
- [zeromq_sub_source_0, '0', qtgui_sink_x_0, '0']
- [zeromq_sub_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
